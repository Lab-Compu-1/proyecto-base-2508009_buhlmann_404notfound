# Repository Lab-Compu-1/proyecto-base-2508009_buhlmann_404notfound

## KiCad design 2534906-GarciaSequeira-MicroDuino/UccMicroDuino/UccMicroDuino.kicad_pcb

Parts:
C1: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: 3.6V 1/2mW; D_SOD-123
D3: PMLL4148L; D_MiniMELF
D4: Led Green; ledSMD
D5: Led Red; ledSMD
J1: USB_A_UCC
J2: Header; PinHeader_1x10_P2.54mm_Vertical
R1, R2: 68Ω 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1.5KΩ 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 330Ω 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ATtiny85-20S; SOIC-8W_5.3x5.3mm_P1.27mm

Connections:
+5V: C1.1, D3.1 (K), D5.2 (A), J2.1, R3.1, U1.8 (VCC)
GND: C1.2, D1.2 (A), D2.2 (A), J1.4 (GND), J2.2, R4.1, R5.2, U1.4 (GND)
unnamed: D1.1 (K), J1.2 (D-), R1.1, R3.2
unnamed: D2.1 (K), J1.3 (D+), R2.1
unnamed: D3.2 (A), J1.1 (VBUS)
unnamed: D4.2 (A), J2.5, U1.6 (PB1)
unnamed: D4.1 (K), R5.1
unnamed: D5.1 (K), R4.2
unnamed: J2.4, U1.5 (AREF/PB0)
unnamed: J2.6, U1.7 (PB2)
unnamed: J2.7, R1.2, U1.2 (XTAL1/PB3)
unnamed: J2.8, R2.2, U1.3 (XTAL2/PB4)
unnamed: J2.9, U1.1 (~RESET/PB5)

Notes on the sheet:
Main Circuit
DC Power
Power Led

Board: 2 copper layers, 45.0 x 45.0 mm, 14 parts (0 on the bottom side), 13 nets.

## Commit log

2025-03-17 Setting up GitHub Classroom Feedback
2025-03-17 GitHub Classroom Feedback
